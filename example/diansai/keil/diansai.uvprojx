# Keil uVision project diansai.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: diansai
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\..\Source\third_party\CMSIS\Core\Include;..\..\..\Source;..\..\diansai;..\Function;..\Hardware
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../../../../mspm0_sdk_2_05_01_00/source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
    ../../../../mspm0_sdk_2_05_01_00/source/ti/driverlib/m0p/: dl_factoryregion.c dl_interrupt.c
    ../../../../mspm0_sdk_2_05_01_00/source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
  group User
    ../: main.c empty.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
  group Startup
    ./: startup_mspm0g350x_uvision.s
  group Function
    ../Function/: board.h bsp_systick.c bsp_systick.h bsp_iic.c bsp_iic.h
  group Hardware
    ../Hardware/: grayscale_sensor.c grayscale_sensor.h oled.c oled.h oledfont.h mpu6050.c mpu6050.h
